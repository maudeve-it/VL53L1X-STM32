<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\VL53L1X_ULD_API_Example.ewp</path>
  </project>
  <batchBuild />
</workspace>
