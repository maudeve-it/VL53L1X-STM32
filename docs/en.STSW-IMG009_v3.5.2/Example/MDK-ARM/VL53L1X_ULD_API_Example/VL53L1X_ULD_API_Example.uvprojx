# Keil uVision project VL53L1X_ULD_API_Example.uvprojx, settings and files
target VL53L1X_ULD_API_Example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: VL53L1X_ULD_API_Example
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ../../Inc;../../Drivers/STM32F4xx_HAL_Driver/Inc;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\BSP\X-NUCLEO-53L1A1;..\..\Drivers\BSP\Components\vl53l1x_uld
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c vl53l1_platform.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/BSP/X-NUCLEO-53L1A1
    ../../Drivers/BSP/X-NUCLEO-53L1A1/: X-NUCLEO-53L1A1.c
  group Drivers/BSP/VL53L1X_ULD
    ../../Drivers/BSP/Components/vl53l1x_uld/: VL53L1X_api.c VL53L1X_calibration.c
software components: CMSIS:CORE 4.1.0
